# Keil uVision project STM32U5x9J-DK_FreeRTOS_Custom.uvprojx, settings and files
target STM32U5x9J-DK_FreeRTOS_Custom (6190000::V6.19::ARMCLANG)
  device: STM32U599NJHx STMicroelectronics
  pack: Keil.STM32U59x_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2026FFFF) IROM(0x08000000-0x83FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32U5x9J-DK_FreeRTOS_Custom +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U599xx
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include/;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/;../Middlewares/Third_Party/CMSIS/RTOS2/Include/;../TouchGFX/gui/include/gui/common;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include;../Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/include;../Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/include
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x270000
  scatter file: .\STM32U5x9J-DK_FreeRTOS_Custom\STM32U5x9J-DK_FreeRTOS_Custom.sct
  group Application/MDK-ARM
    ./: startup_stm32u599xx.s
  group Application/User/Core
    ../Core/Src/: retarget.c main.c gpio.c app_freertos.c crc.c dcache.c dma2d.c dsihost.c gpu2d.c i2c.c icache.c ltdc.c octospi.c tim.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: Buttons.cpp CortexMMCUInstrumentation.cpp KeySampler.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp nema_hal.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dsi.c stm32u5xx_hal_gpu2d.c stm32u5xx_hal_xspi.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_ltdc.c stm32u5xx_hal_ltdc_ex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group gui
    ../touchgfx/gui/src/fontscreen_screen/: fontscreenpresenter.cpp fontscreenview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp koreanfusionletters.cpp lcdfusion.cpp malgunbd_ttf_kern.cpp vectorfontscale.c
    ../touchgfx/gui/src/mainscreen_screen/: mainscreenpresenter.cpp mainscreenview.cpp
    ../touchgfx/gui/src/model/: model.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_samsungonekorean_700_v2_0_hinted_20200508_30_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdanab_20_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_samsungonekorean_700_v2_0_hinted_20200508_30_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdanab_20_4bpp.cpp table_samsungonekorean_700_v2_0_hinted_20200508_30_4bpp.cpp table_verdana_20_4bpp.cpp table_verdanab_20_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_subbrand_stm32-2_stm32_00.cpp image_subbrand_stm32-2_stm32_01.cpp image_subbrand_stm32-2_stm32_02.cpp image_subbrand_stm32-2_stm32_03.cpp image_subbrand_stm32-2_stm32_04.cpp image_subbrand_stm32-2_stm32_05.cpp image_subbrand_stm32-2_stm32_06.cpp image_subbrand_stm32-2_stm32_07.cpp image_subbrand_stm32-2_stm32_08.cpp image_subbrand_stm32-2_stm32_09.cpp image_subbrand_stm32-2_stm32_10.cpp image_subbrand_stm32-2_stm32_11.cpp image_subbrand_stm32-2_stm32_12.cpp image_subbrand_stm32-2_stm32_13.cpp image_subbrand_stm32-2_stm32_14.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/fontscreen_screen/: fontscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/mainscreen_screen/: mainscreenviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m33/Keil6.x/: touchgfx_core_wchar16.lib
    ../Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/lib/core/cortex_m33/Keil6.x/: nemagfx_core_release-wchar16.lib
    ../Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/lib/cortex_m33/Keil6.x/: touchgfxnema_release-wchar16.lib
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.3.0
